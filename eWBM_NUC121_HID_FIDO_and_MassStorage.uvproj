# Keil uVision project eWBM_NUC121_HID_FIDO_and_MassStorage.uvproj, settings and files
target HID_FIDO_and_MassStorage (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: NUC121SC2AE Nuvoton
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0-0x7FFF) CLOCK(50000000) CPUTYPE("Cortex-M0")
  output: eWBM_HID_FIDO_and_MassStorage +hex
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: OneElfS=1
  c define: NO_MASS_STORAGE,BULK_TRANSFER,NO_SPI_16_BIT
  c include: .\driver\CMSIS\Include;.\driver\Device\Nuvoton\NUC121\Include;.\driver\StdDriver\inc;.\application\include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: --map --first='startup_NUC121.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group Application
    ./application/: main.c
    ./application/source/: HID_FIDO_and_MassStorage.c descriptors.c SPIFlash.c USPIComm.c
  group Device
    ./driver/Device/Nuvoton/NUC121/Source/: system_NUC121.c
    ./driver/Device/Nuvoton/NUC121/Source/ARM/: startup_NUC121.s
  group Driver
    ./driver/StdDriver/src/: retarget.c usbd.c sys.c clk.c fmc.c spi_i2s.c usci_spi.c gpio.c
